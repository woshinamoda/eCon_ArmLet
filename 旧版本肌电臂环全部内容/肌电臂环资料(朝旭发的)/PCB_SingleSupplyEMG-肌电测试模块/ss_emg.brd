# Repository woshinamoda/eCon_ArmLet

File README.md:

## 肌电臂环集合内容（包含老版和新版全部代码与原理图，详细说明请参考项目说明）
### 更新记录
---
更新日期：2022/08/30<br>
 * 1.修改存在的错别字
 * 2.新版臂环和老版臂环分隔开<br>
  本仓库只存储老版本肌电臂环程序与对应内容
---

更新日期：2022/08/29<br>

 * 1.新增修改github上关于肌电臂环梳理内容
 * 2.验证老版本臂环程序matlab内容<br>
  	修改对应老版臂环说明书
	* 详情参考 旧版肌电臂环全部内容<br>
				->重要文档
					—>《肌电臂环说明书V0.0.1》

---

### 项目说明
- doc：内部包含新版本肌电臂环工作计划与讨论的设计开发内容梳理
- Software：新版本肌电臂环程序，基于nrf52832设计
- Hardware：新版本肌电臂环原理图设计
- 旧版本肌电臂环全部内容
	* 1 ：20套肌电臂环单电源测试流程 ： 测试21年10月左右生产的臂环是否有问题
	* 2 : ARMletV0.0.0
	* 3 : ARMletV0.1.1
	* 4 : ARMletV0.1.2
	* 5 : ARMletV1.0.0	：	没有IMU程序
	* 6 : ARMletV1.0.1	：	发给字节跳动带有IMU的程序
	* 7 : BlurTooth_doc	：	飞易通和翌虹的蓝牙模块资料汇总
	* 8 : 肌电臂环生产检测入库文件
	* 9 : 测试流程18套成品肌电臂环
	* 10: matlab离线在线代码
		* 1-> read_data_offline.m ： 离线测试肌电臂环EMG与IMU 信号完整度的测试代码
		* 2-> read_data_online.m  ： 在线观察肌电臂环8个通道RMG与三个方向IMU 信号连续都的测试代码
	* 11: 重要文档
	* 12: read_data.m：用于检测老版本臂环功能的matlab代码

## EAGLE design 旧版本肌电臂环全部内容/肌电臂环资料(朝旭发的)/PCB_SingleSupplyEMG-肌电测试模块/ss_emg.brd

Parts:
C1: 1u; C0402
C2, C3: 100nf; C0402
C4: 10uf; C0402
C5: 6.8nf; C0402
IC1: AD8607RM; MSOP08
J1, J3: 2p-2.54; H2-2.54
J2: 4p-2.54; H4-2.54
R2, R3: 1K; R0402
R4: 50K; R0402
R5, R6: 10K; R0402
U$1: AD8221; MSOP08

Connections:
3.7V: C1.1, C2.2, C3.1, IC1.8 (V+), J1.1, R5.1, U$1.8 (+VS)
GND: C1.2, C2.1, C3.2, IC1.4 (V-), J1.2, J2.2, J3.2, R6.1, U$1.5 (-VS)
IN+: J2.4, U$1.4 (+IN)
IN-: J2.1, U$1.1 (-IN)
unnamed: R2.2, U$1.2 (RG1)
unnamed: R2.1, U$1.3 (RG2)
unnamed: C4.2, R3.1
unnamed: C5.1, IC1.2 (IN-), R3.2, R4.1
unnamed: IC1.5 (IN+), R5.2, R6.2
REF: IC1.3 (IN+), IC1.6 (IN-), IC1.7 (OUT), J2.3, U$1.6 (REF)
SIGNAL: C5.2, IC1.1 (OUT), J3.1, R4.2
VOUT: C4.1, U$1.7 (VOUT)

Board: 2 copper layers, 25.0 x 18.0 mm, 15 parts (0 on the bottom side), 12 nets.

## EAGLE design 旧版本肌电臂环全部内容/肌电臂环资料(朝旭发的)/band4.0-蓝牙的主从/host/host.brd

Parts:
ANT1: ANT8030-2R4-01A; ANTENNA
C1: 0.1uf; C0402
C2, C7, C14, C15: 1uf; C0402
C3, C4, C5, C6: 12pf; C0402
C8, C9, C12: 100nf; C0402
C10: 100pf; C0402
C11: 0.8pf; C0402
C13: 4.7uf; C0402
CP1: CP2102; QFN28G_0.5-5X5MM
D1, D2: red; LED-0402
L1: 3.9nh; L0402
L2: 10uh; L0402
L3: 15nh; L0402
R2: 4.7k; R0402
R3, R4, R7: 10k; R0402
R5: 1k; R0402
R6: 0R; R0603
U1: USB-4PIN; USB-HW-4PIN
U2: RF-51822; QFN48G-0.4-6X6MM
U$1: RT9013; SC-70-5
X-1: 32.768KHZ
X-2: 32MHZ; 16MHZ

Connections:
+3V3: C9.2, C12.2, C13.2, C15.1, R5.2, U2.13 (VDD1), U2.36 (VDD2), U2.48 (VDD3), U$1.4 (NC)
+5V: C2.1, C14.1, CP1.7 (REGIN), CP1.8 (VBUS), U1.P$1 (VCC), U$1.1 (VIN), U$1.3 (EN)
CTS: CP1.23 (CTS), U2.9 (P0.07)
D+: CP1.4 (D+), U1.P$3 (D+)
D-: CP1.5 (D-), U1.P$2 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.2, C8.1, C9.1, C10.2, C11.1, C12.1, C13.1, C14.2, C15.2, CP1.3 (GND), CP1.29 (HEAT_TAB), R3.2, R7.2, U1.P$4 (GND), U2.31 (VSS1), U2.45 (VSS3), U2.PAD, U$1.2 (GND)
unnamed: CP1.9 (*RST), R2.1
unnamed: CP1.11 (*SUSPEND), R3.1
unnamed: CP1.12 (SUSPEND), R4.2
unnamed: C8.2, U2.1 (DEC1)
unnamed: D1.-, R4.1
unnamed: C3.1, U2.2 (XL1), X-1.P$2 (2)
unnamed: C4.1, U2.3 (XL2), X-1.P$1 (1)
unnamed: D2.+, R5.1
unnamed: D2.-, U2.20 (P0.17)
unnamed: R6.2, R7.1, U2.25 (SWDCLK)
unnamed: R6.1, U2.26 (SWDIO)
unnamed: ANT1.1, L1.2
unnamed: C11.2, L1.1, U2.30 (ANT)
unnamed: C10.1, U2.33 (DEC3)
unnamed: C6.2, U2.34 (XC1), X-2.1
unnamed: C5.2, U2.35 (XC2), X-2.3 (2)
unnamed: L2.2, L3.1
unnamed: L2.1, U2.47 (DCC)
unnamed: C7.1, L3.2, U2.46 (DEC4)
RTS: CP1.24 (RTS), U2.7 (P0.05)
UART1_RX: CP1.25 (RXD), U2.8 (P0.06)
UART1_TX: CP1.26 (TXD), U2.10 (P0.08)
VD: C1.1, CP1.6 (VDD), D1.+, R2.2

Board: 2 copper layers, 19.0 x 12.0 mm, 33 parts (15 on the bottom side), 29 nets.

## EAGLE design 旧版本肌电臂环全部内容/肌电臂环资料(朝旭发的)/Newarm/HandBand_HW/HW1.0/band4.0.brd

Parts:
ANT1: AH316M245001; ANT2-SMD-3.2X1.6X0.5MM
C1, C5, C6, C7, C13, C14, C19, C20: 0.1uf; C0402
C2, C3: 20pf; C0402
C4, C8, C9, C27: 4.7uf; C0402
C12: 10nf; C0402
C15: 2.2nf; C0402
C18, C21, C26: 100nf; C0402
C22: 0.8pf; C0402
C23: 100pf; C0402
C24, C25: 12pf; C0402
C28, C29, C30, C31, C32: 1uf; C0402
D1: LED-(0402); LED-0402
D2: BLUE-0402; LED-0402
FPC-12-1, FPC-12-2: FPC-12
L1: 3.9nh; L0402
M-1: MOTOR
MCP73831-1: MCP73831; SOT23-5
MCU-1: STM32F411; QFN48G-0.5-7X7MM
MIC-1: MIC5528; THIN-DFN
MPU6050-1: MPU-6050; QFN24-4X4
R1, R3, R6, R9, R15, R22, R23: 10k; R0402
R2: 0R; R0402
R4: 470R; R0402
R5, R10: 1k; R0402
R7, R8, R11, R19, R21: NC; 0201
R13, R16, R17, R18: 2k; R0402
R14: 20k; R0402
R20: 47k; R0402
R24: 0R; 0201
RGB-1: RGB-LED
SW1: SMD-BUTTON(2P-6.0X3.0X2.5MM)-DHT-1163S; SW2-4.0-6.0X3.0X2.5MM
T1: NTS2101PT1G; SC70
U1: PNP
U2: RF-51822; QFN48G-0.4-6X6MM
USB1: ZX62-B-5PA; MICRO-USB5+6P-SMD-0.65-AB
X-1: 16MHZ
X-3: 32MHZ; 16MHZ

Connections:
+3.7V: C9.2, FPC-12-1.P$7, MCP73831-1.3 (VBAT), R24.1
+3V3: C1.2, C5.1, C6.1, C7.2, C12.2, C14.2, C20.2, C29.2, C30.2, MCU-1.1 (VBAT), MCU-1.9 (VREF+), MCU-1.24 (VDD), MCU-1.36 (VDD1), MCU-1.48 (VDD2), MIC-1.1 (VOUT1), MPU6050-1.8 (VLOGIC), MPU6050-1.13 (VDD), R3.2, R20.2, R22.2, R23.2, RGB-1.P$1 (VCC), T1.2 (S), U1.2 (E)
+5V: C8.2, D1.+, MCP73831-1.4 (VDD), R15.1, USB1.1 (VBUS)
BLE_EN: MCU-1.27 (PB14), R5.2
BT_CONTROL: MCU-1.21 (PB10), R20.1, T1.1 (G)
BT_POWER: C18.2, C26.1, C27.1, T1.3 (D), U2.13 (VDD1), U2.36 (VDD2), U2.48 (VDD3)
GND: C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, C7.1, C8.1, C9.1, C12.1, C13.1, C14.1, C15.1, C18.1, C19.1, C20.1, C21.1, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.1, C29.1, C30.1, C31.1, C32.1, D2.-, FPC-12-1.P$6, FPC-12-1.P$8, M-1.1 (-), MCP73831-1.2 (VSS), MCU-1.8 (VREF-), MCU-1.23 (VSS), MCU-1.35 (VSS1), MCU-1.47 (VSS2), MCU-1.PAD (EXP), MIC-1.3 (GND), MIC-1.7 (GND), MPU6050-1.1 (CLKIN), MPU6050-1.9 (AD0), MPU6050-1.11 (FSYNC), MPU6050-1.18 (GND), MPU6050-1.EXP, R1.1, R9.2, R11.1, R13.1, R14.2, R19.1, U2.31 (VSS1), U2.45 (VSS3), U2.PAD, USB1.5 (GND), USB1.P1 (SHIELD), USB1.P2 (SHIELD), USB1.P3 (SHIELD), USB1.P4 (SHIELD), USB1.P5 (SHIELD), USB1.P6 (SHIELD)
IIC2_SCL: MCU-1.45 (PB8), MPU6050-1.23 (SCL), R22.1
IIC2_SDA: MCU-1.46 (PB9), MPU6050-1.24 (SDA), R23.1
LED1: MCU-1.38 (PA15), R17.1
LED2: MCU-1.39 (PB3), R18.1
LED3: MCU-1.40 (PB4), R16.2
LI_BAT1: MCU-1.19 (PB1), R6.2, R9.1
LI_BAT2: MCU-1.28 (PB15), R14.1, R15.2
MOTOR_CONTROL: MCU-1.43 (PB7), R3.1, U1.1 (B)
unnamed: C2.2, MCU-1.5 (OSC_IN), X-1.3 (2)
unnamed: C3.2, MCU-1.6 (OSC_OUT), X-1.1
unnamed: C19.2, MCU-1.7 (NRST)
unnamed: MCU-1.10 (PA0), R2.2
unnamed: MCP73831-1.1 (STAT), R4.1
unnamed: D1.-, R4.2
unnamed: MCP73831-1.5 (PROG), R13.2
unnamed: R16.1, RGB-1.P$4
unnamed: R17.2, RGB-1.P$3
unnamed: R18.2, RGB-1.P$2
unnamed: C21.2, U2.1 (DEC1)
unnamed: C13.2, MPU6050-1.10 (REGOUT)
unnamed: R10.1, U2.19 (P0.16)
unnamed: L1.2, R11.2, R21.2
unnamed: C15.2, MPU6050-1.20 (CPOUT)
unnamed: ANT1.1, R19.2, R21.1
unnamed: D2.+, R10.2
unnamed: R5.1, U2.21 (P0.18)
unnamed: MCU-1.44 (BOOT0), R1.2
unnamed: C28.2, U2.46 (DEC4)
unnamed: C32.2, MIC-1.4 (EN), MIC-1.6 (VIN), R6.1, R24.2
unnamed: C4.2, MCU-1.22 (VCAP1)
unnamed: M-1.2 (+), U1.3 (C)
unnamed: C22.1, L1.1, U2.30 (ANT)
unnamed: C23.1, U2.33 (DEC3)
unnamed: C24.1, U2.34 (XC1), X-3.1
unnamed: C25.1, U2.35 (XC2), X-3.3 (2)
SWCLK: MCU-1.37 (PA14), R7.1
SWDIO: MCU-1.34 (PA13), R8.1
UART1_RX: MCU-1.31 (PA10), U2.17 (P0.14)
UART1_TX: MCU-1.30 (PA9), U2.18 (P0.15)
USB_PORT2: R7.2, USB1.3 (D+)
USB_PORT3: R8.2, USB1.2 (D-)
V1: FPC-12-1.P$10, MCU-1.13 (PA3)
V2: FPC-12-1.P$11, MCU-1.12 (PA2)
V3: FPC-12-1.P$12, MCU-1.11 (PA1)
V4: FPC-12-1.P$1, MCU-1.14 (PA4)
V5: FPC-12-1.P$2, MCU-1.15 (PA5)
V6: FPC-12-1.P$3, MCU-1.16 (PA6)
V7: FPC-12-1.P$4, MCU-1.17 (PA7)
V8: FPC-12-1.P$5, MCU-1.18 (PB0)
VCC_NEXT: C31.2, FPC-12-1.P$9, MIC-1.2 (VOUT2)
WKUP: MPU6050-1.12 (INT), R2.1

Notes on the sheet:
主控及震动反馈
电源管理及状态指示
蓝牙的电源控制
BLE4.0
连接件
R3大小

Board: 4 copper layers, 37.5 x 17.5 mm, 70 parts (15 on the bottom side), 58 nets.

## EAGLE design 旧版本肌电臂环全部内容/肌电臂环资料(朝旭发的)/band4.0-蓝牙的主从/slave/band4.0.brd

Board: 4 copper layers, 37.5 x 17.5 mm, 83 parts (33 on the bottom side), 66 nets.

Parts:
ANT1: ANT8030-2R4-01A; ANTENNA
C1, C5, C6, C7, C13, C14: 0.1uf; C0402
C2, C3: 20pf; C0402
C4, C8, C9, C27: 4.7uf; C0402
C10: 10uf; C0402
C11, C28: 1uf; C0402
C12: 10nf; C0402
C15: 2.2nf; C0402
C16, C17, C24, C25: 12pf; C0402
C18, C21, C26: 100nf; C0402
C22: 0.8pf; C0402
C23: 100pf; C0402
D1, D2: BLUE-0402; LED-0402
FPC-12-1: FPC-12
L1: 3.9nh; L0402
L2: 10uh; L0402
L3: 15nh; L0402
M-1: MOTOR
MCP73831-1: MCP73831; SOT23-5
MPU6050-1: MPU-6050; QFN24-4X4
R1, R14, R19, R20, R22, R23, R29: 10k; R0402
R2, R3, R5, R6, R7, R8, R11, R21, R24, R25, R26, R27, R28: 0R; R0402
R4: 470R; R0402
R9: 1.5k; R0402
R10: 1k; R0402
R13, R16, R17, R18: 2k; R0402
R15: 20k; R0402
RGB-1: RGB-LED
STM32F411-1: STM32F411; QFN48-7X7
U1, U3: PNP
U2: RF-51822; QFN48G-0.4-6X6MM
U$1: RT9013; SC-70-5
U$2, U$3, U$4, U$5, U$6, U$7, U$8, U$9, U$10: TEST-POINT
USB1: ZX62-B-5PA; MICRO-USB5+6P-SMD-0.65-AB
X-1: 16MHZ
X-2: 32.768KHZ
X-3: 32MHZ; 16MHZ

Connections:
+3.7V: C9.2, FPC-12-1.P$7, MCP73831-1.3, R21.2
+3V3: C1.2, C5.1, C6.1, C7.2, C11.2, C12.2, C14.2, FPC-12-1.P$9, MPU6050-1.8, MPU6050-1.13, R1.1, R3.2, R9.1, R11.2, R22.2, R23.2, RGB-1.P$1, STM32F411-1.1, STM32F411-1.9, STM32F411-1.24, STM32F411-1.36, STM32F411-1.48, U$1.5, U$5.P$1
+5V: C8.2, D1.+, MCP73831-1.4, R15.1, USB1.1
BT_CONTROL: STM32F411-1.26, U3.1
BT_POWER: C18.2, C26.1, C27.1, R10.1, U2.13, U2.36, U2.48, U3.3
GND: C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C21.1, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.1, FPC-12-1.P$6, FPC-12-1.P$8, M-1.1, MCP73831-1.2, MPU6050-1.1, MPU6050-1.9, MPU6050-1.11, MPU6050-1.18, MPU6050-1.EXP, R13.1, R14.2, R19.2, R29.1, STM32F411-1.8, STM32F411-1.23, STM32F411-1.35, STM32F411-1.44, STM32F411-1.47, STM32F411-1.EXP, U2.31, U2.45, U2.PAD, U$1.2, U$6.P$1, USB1.5, USB1.P1, USB1.P2, USB1.P3, USB1.P4, USB1.P5, USB1.P6
IIC2_SCL: MPU6050-1.23, R22.1, STM32F411-1.45
IIC2_SDA: MPU6050-1.24, R23.1, STM32F411-1.46
LED1: R17.1, STM32F411-1.38
LED2: R18.1, STM32F411-1.39
LED3: R16.2, STM32F411-1.40
LI_BAT1: R19.1, R20.2, STM32F411-1.19
LI_BAT2: R14.1, R15.2, STM32F411-1.28
MOTOR_CONTROL: STM32F411-1.25, U1.1
unnamed: C2.2, STM32F411-1.5, X-1.3
unnamed: C3.2, STM32F411-1.6, X-1.1
unnamed: R1.2, STM32F411-1.7
unnamed: R2.2, STM32F411-1.10
unnamed: MCP73831-1.1, R4.1
unnamed: D1.-, R4.2
unnamed: MCP73831-1.5, R13.2
unnamed: R16.1, RGB-1.P$4
unnamed: R17.2, RGB-1.P$2
unnamed: R18.2, RGB-1.P$3
unnamed: C21.2, U2.1
unnamed: C13.2, MPU6050-1.10
unnamed: C16.2, U2.2, X-2.P$2
unnamed: C10.2, R20.1, R21.1, U$1.1, U$1.3
unnamed: C15.2, MPU6050-1.20
unnamed: C17.2, U2.3, X-2.P$1
unnamed: R25.2, U2.8, U$10.P$1
unnamed: R24.2, U2.16
unnamed: D2.+, R10.2
unnamed: R26.2, U2.10, U$9.P$1
unnamed: D2.-, U2.20
unnamed: R11.1, U3.2
unnamed: R27.2, R29.2, U2.25, U$8.P$1
unnamed: R28.2, U2.26, U$7.P$1
unnamed: ANT1.1, L1.2
unnamed: C4.2, STM32F411-1.22
unnamed: M-1.2, U1.3
unnamed: R3.1, U1.2
unnamed: C22.1, L1.1, U2.30
unnamed: C23.1, U2.33
unnamed: C24.1, U2.34, X-3.1
unnamed: C25.1, U2.35, X-3.3
unnamed: L2.2, L3.1
unnamed: L2.1, U2.47
unnamed: C28.2, L3.2, U2.46
SWCLK: R5.1, STM32F411-1.37, U$2.P$1
SWDIO: R6.1, STM32F411-1.34, U$3.P$1
UART1_RX: R25.1, STM32F411-1.31
UART1_TX: R26.1, STM32F411-1.30
USB_D+: R8.1, R9.2, STM32F411-1.33
USB_D-: R7.1, STM32F411-1.32
USB_PORT2: R5.2, R7.2, R27.1, USB1.3
USB_PORT3: R6.2, R8.2, R28.1, USB1.2
V1: FPC-12-1.P$10, STM32F411-1.13
V2: FPC-12-1.P$11, STM32F411-1.12
V3: FPC-12-1.P$12, STM32F411-1.11
V4: FPC-12-1.P$1, STM32F411-1.14
V5: FPC-12-1.P$2, STM32F411-1.15
V6: FPC-12-1.P$3, STM32F411-1.16
V7: FPC-12-1.P$4, STM32F411-1.17
V8: FPC-12-1.P$5, STM32F411-1.18
WKUP: MPU6050-1.12, R2.1, R24.1, U$4.P$1

## Code that names these connections

File 旧版本肌电臂环全部内容/肌电臂环资料(朝旭发的)/Newarm/HandBand_SW/SW1/SW1.ioc (part):

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Mcu.Name=STM32F411C(C-E)Ux
Mcu.Package=UFQFPN48
Mcu.UserName=STM32F411CEUx
PA0-WKUP.Mode=SYS_WakeUp0
PA0-WKUP.Signal=SYS_WKUP
PA1.Signal=ADCx_IN1
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=PinState,GPIO_Label
PA15.GPIO_Label=LED1
PA15.PinState=GPIO_PIN_SET
PA15.Signal=GPIO_Output
PA2.Signal=ADCx_IN2
PA3.Signal=ADCx_IN3
PA4.Signal=ADCx_IN4
PA5.Signal=ADCx_IN5
PA6.Signal=ADCx_IN6
PA7.Signal=ADCx_IN7
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.Signal=ADCx_IN8
PB1.Signal=ADCx_IN9
PB10.GPIOParameters=PinState,GPIO_Label
PB10.GPIO_Label=BT_CTRL
PB10.PinState=GPIO_PIN_RESET
PB10.Signal=GPIO_Output
PB14.GPIOParameters=PinState,GPIO_Label
PB14.GPIO_Label=BLE_EN
PB14.PinState=GPIO_PIN_SET
PB14.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_PuPd,GPIO_ModeDefaultEXTI
PB15.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING
PB15.GPIO_PuPd=GPIO_PULLDOWN
PB15.Signal=GPXTI15
PB3.GPIOParameters=PinState,GPIO_Label
PB3.GPIO_Label=LED2
PB3.PinState=GPIO_PIN_SET
PB3.Signal=GPIO_Output
PB4.GPIOParameters=PinState,GPIO_Label
PB4.GPIO_Label=LED3
PB4.PinState=GPIO_PIN_SET
PB4.Signal=GPIO_Output
PB7.GPIOParameters=PinState,GPIO_Label
PB7.GPIO_Label=MOTOR_CTRL
PB7.PinState=GPIO_PIN_SET
PB7.Signal=GPIO_Output
PB8.GPIOParameters=GPIO_Speed,PinState,GPIO_Label,GPIO_ModeDefaultOutputPP
PB8.GPIO_Label=IIC_SCL
PB8.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB8.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB8.PinState=GPIO_PIN_SET
PB8.Signal=GPIO_Output
PB9.GPIOParameters=GPIO_Speed,PinState,GPIO_Label,GPIO_ModeDefaultOutputPP
PB9.GPIO_Label=IIC_SDA
PB9.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB9.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB9.PinState=GPIO_PIN_SET
PB9.Signal=GPIO_Output
PH0\ -\ OSC_IN.Mode=HSE-External-Oscillator
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PH1\ -\ OSC_OUT.Mode=HSE-External-Oscillator
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=16000000
RCC.SYSCLKFreq_VALUE=100000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2022-08-29 first push EconARMlet datas
2022-08-30 only old armlet
